# Keil uVision project Project.uvprojx, settings and files
target Project template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Dirver\Drv_dev\Inc;..\Core\Inc;..\Dirver\Drv_per\Inc;..\Usb_Device\STM32_USB_Device_Library\Class\HID\Inc;..\Usb_Device\STM32_USB_Device_Library\Core\Inc;..\Usb_Device\USB_DEVICE\Target;..\Usb_Device\USB_DEVICE\App;..\Usb_Device\Inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\ThirdParty\lvgl
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../Core/Src/: main.c systick.c
  group Driver_per
    ../Dirver/Drv_per/Src/: gpio.c uart.c spi.c
  group Driver_dev
    ../Dirver/Drv_dev/Src/: led.c key.c pwm3360.c srom.c mouse.c esp32_link.c
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
  group Usb_Device
    ../Usb_Device/Src/: usb_hw.c usb_desc.c usb_core.c
  group Si24R1
    ../Dirver/Drv_dev/Src/si24r1/: si24r1_app.c si24r1_core.c si24r1_hw.c si24r1_link.c
  group FreeRTOS_App
    ../Core/Src/: retarget.c app_rtos.c
    ../Dirver/Drv_dev/Src/si24r1/: si24r1_rtos.c
    ../FreeRTOS/: tasks.c queue.c list.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group Mouse_UI
    ../Dirver/Drv_dev/Src/: touch_xpt2046.c lcd_st7796.c touch_gt9xx.c
    ../Core/Src/: ui_font_16.c ui_font_20.c app_ui.c
    ../Dirver/Drv_per/Src/: lcd_bus.c
  group LVGL_8_4
    ../ThirdParty/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev_scroll.c lv_indev.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style_gen.c lv_obj_style.c lv_obj_tree.c lv_obj.c lv_refr.c lv_theme.c
    ../ThirdParty/lvgl/src/draw/: lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_draw.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../ThirdParty/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../ThirdParty/lvgl/src/draw/nxp/pxp/: lv_draw_pxp_blend.c lv_draw_pxp.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp.c
    ../ThirdParty/lvgl/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_draw_vglite.c lv_vglite_buf.c lv_vglite_utils.c
    ../ThirdParty/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../ThirdParty/lvgl/src/draw/sdl/: lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c lv_draw_sdl.c
    ../ThirdParty/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../ThirdParty/lvgl/src/draw/sw/: lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c lv_draw_sw.c
    ../ThirdParty/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../ThirdParty/lvgl/src/extra/: lv_extra.c
    ../ThirdParty/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../ThirdParty/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../ThirdParty/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../ThirdParty/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../ThirdParty/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../ThirdParty/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../ThirdParty/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../ThirdParty/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../ThirdParty/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../ThirdParty/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../ThirdParty/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../ThirdParty/lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../ThirdParty/lvgl/src/extra/others/fragment/: lv_fragment_manager.c lv_fragment.c
    ../ThirdParty/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../ThirdParty/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../ThirdParty/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../ThirdParty/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../ThirdParty/lvgl/src/extra/others/msg/: lv_msg.c
    ../ThirdParty/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../ThirdParty/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../ThirdParty/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../ThirdParty/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../ThirdParty/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../ThirdParty/lvgl/src/extra/widgets/calendar/: lv_calendar_header_arrow.c lv_calendar_header_dropdown.c lv_calendar.c
    ../ThirdParty/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../ThirdParty/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../ThirdParty/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../ThirdParty/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../ThirdParty/lvgl/src/extra/widgets/led/: lv_led.c
    ../ThirdParty/lvgl/src/extra/widgets/list/: lv_list.c
    ../ThirdParty/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../ThirdParty/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../ThirdParty/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../ThirdParty/lvgl/src/extra/widgets/span/: lv_span.c
    ../ThirdParty/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../ThirdParty/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../ThirdParty/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../ThirdParty/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../ThirdParty/lvgl/src/extra/widgets/win/: lv_win.c
    ../ThirdParty/lvgl/src/font/: lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_16.c lv_font_montserrat_20.c lv_font_montserrat_28.c lv_font.c
    ../ThirdParty/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../ThirdParty/lvgl/src/misc/: lv_anim_timeline.c lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style_gen.c lv_style.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt_ap.c lv_txt.c lv_utils.c
    ../ThirdParty/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
