## Esp32Mouse/sdkconfig.defaults
```kconfig
# BLE HID 需要的蓝牙配置（Bluedroid + BLE）
CONFIG_BT_ENABLED=y
CONFIG_BT_BLUEDROID_ENABLED=y
CONFIG_BT_BLE_ENABLED=y
CONFIG_BT_BLE_42_FEATURES_SUPPORTED=y
```
